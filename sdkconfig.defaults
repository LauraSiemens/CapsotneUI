## sdkconfig.defaults
```kconfig
# Free internal RAM for WiFi + WebSocket (Classic BT disabled)
CONFIG_BT_ENABLED=n
```
